require rpi5-image-minimal-domd.bb

IMAGE_INSTALL:append = " i2c-tools"
